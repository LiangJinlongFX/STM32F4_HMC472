# Keil uVision project STM32F407VET6.uvprojx, settings and files
target Target 1 (5060183::V5.06 update 2 (build 183)::ARMCC)
  device: STM32F407VETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.10.0
  cpu: IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: STM32F407VET6
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER
  c include: ..\Common\delay;..\Common\sys;..\Common\usart;..\CORE;..\STM32F4_LIB\inc;..\SYSTEM;..\BSP\LED;..\Common\Contr_Pin;..\BSP\LCD;..\Driver\keyboard;..\BSP\SPI;..\Driver\HMC472;..\BSP\DAC;..\BSP\ADC;..\USER
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group CORE
    ../CORE/: core_cm4.h core_cm4_simd.h core_cmFunc.h core_cmInstr.h startup_stm32f40_41xxx.s
  group SYSTEM
    ../SYSTEM/: main.c stm32f4xx_it.c system_stm32f4xx.c stm32f4xx_conf.h
  group STM32F4_LIB
    ../STM32F4_LIB/src/: misc.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_gpio.c stm32f4xx_fsmc.c stm32f4xx_rtc.c stm32f4xx_usart.c stm32f4xx_rcc.c stm32f4xx_dac.c stm32f4xx_adc.c stm32f4xx_dma.c
  group Driver
    ../Driver/keyboard/: keyboard.c
    ../Driver/HMC472/: hmc472.c
  group Common
    ../Common/delay/: delay.c
    ../Common/sys/: sys.c
    ../Common/Contr_Pin/: IO.c
    ../Common/usart/: usart.c
  group BSP
    ../BSP/LED/: led.c
    ../BSP/LCD/: lcd.c
    ../BSP/ADC/: adc.c
